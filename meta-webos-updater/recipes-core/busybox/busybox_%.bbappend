# Copyright (c) 2019 LG Electronics, Inc.

EXTENDPRAUTO:append = "webosupdater1"

RPROVIDES:${PN}_sota += "/bin/bash"
