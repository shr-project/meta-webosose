# Copyright (c) 2022 LG Electronics, Inc.

EXTENDPRAUTO:append = "webosupdater1"

# Backport https://github.com/uptane/meta-updater/pull/42
LICENSE = "BSD-2-Clause"
