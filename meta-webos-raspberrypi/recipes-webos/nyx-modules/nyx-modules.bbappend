# Copyright (c) 2020 LG Electronics, Inc.

EXTENDPRAUTO:append = "webosrpi4"

DEPENDS:append = " nmeaparser"

NYX_MODULES_REQUIRED:append = "NYXMOD_OW_GPS;"
