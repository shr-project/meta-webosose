# Backport changes from:
# https://lists.openembedded.org/g/openembedded-devel/message/104710
# https://lists.openembedded.org/g/openembedded-devel/message/104709
# https://lists.openembedded.org/g/openembedded-devel/message/104708
# https://git.openembedded.org/meta-openembedded/commit/?id=c902a85099596136e850636192458d1cdac6c9a4
# https://git.openembedded.org/meta-openembedded/commit/?h=mickledore&id=facddc3141cdcff181cca46914d6d0e26d994931
inherit fix_branch_name
