# Branches used in langdale, mickledore, nanbield were re-written in upstream :(, fixes sent to meta-oe:
# langdale: https://lists.openembedded.org/g/openembedded-devel/message/107533
# mickledore: https://lists.openembedded.org/g/openembedded-devel/message/107531
# nanbield: https://lists.openembedded.org/g/openembedded-devel/message/107532
inherit fix_branch_name
FIX_BRANCH_TO = "nobranch=1"
