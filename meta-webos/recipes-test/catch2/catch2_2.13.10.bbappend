# http://gecko.lge.com:8000/Errors/Details/833763
# lib32-catch2/2.13.10/git/projects/SelfTest/UsageTests/ToStringGeneral.tests.cpp:122:32: error: value computed is not used [-Werror=unused-value]
CXXFLAGS += "-Wno-error=unused-value"
