# Fails to build with gold

EXTRA_OECONF:append:class-target:x86 = " --disable-gprofng"
GPROFNG_ALTS:class-target:x86 = ""
