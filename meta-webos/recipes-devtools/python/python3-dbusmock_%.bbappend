inherit features_check

REQUIRED_DISTRO_FEATURES = "gobject-introspection-data"
