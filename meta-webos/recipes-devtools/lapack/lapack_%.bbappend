# Copyright (c) 2019-2024 LG Electronics, Inc.

EXTENDPRAUTO = "webos2"

PACKAGECONFIG = "cblas"
