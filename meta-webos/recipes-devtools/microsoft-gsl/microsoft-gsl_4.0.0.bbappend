# http://gecko.lge.com:8000/Errors/Details/833765
# lib32-microsoft-gsl/4.0.0/git/tests/span_tests.cpp:1275:34: error: value computed is not used [-Werror=unused-value]
CXXFLAGS += "-Wno-error=unused-value"
