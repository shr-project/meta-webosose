
# FIXME-buildpaths!!!
# [WRP-10883] buildpath QA issues
# https://bugreports.qt.io/browse/QTBUG-105913
# http://gecko.lge.com:8000/Errors/Details/895284
# ERROR: QA Issue: File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/effects_qt6/.qt/rcc/qrc_qmake_QtQuick_Studio_Effects.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/effects_qt6/.qt/rcc/qrc_QuickStudioEffects_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/flowview/.qt/rcc/qrc_FlowView_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/utils/.qt/rcc/qrc_QuickStudioUtils_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/utils/.qt/rcc/qrc_qmake_QtQuick_Studio_Utils.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/logichelper/.qt/rcc/qrc_QuickStudioLogicHelper_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/logichelper/.qt/rcc/qrc_qmake_QtQuick_Studio_LogicHelper.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/multitext/.qt/rcc/qrc_qmake_QtQuick_Studio_MultiText.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/multitext/.qt/rcc/qrc_QuickStudioMultiText_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/tools/eventsimulator/.qt/rcc/qrc_QuickStudioEventSimulator_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/tools/eventsimulator/.qt/rcc/qrc_qmake_QtQuick_Studio_EventSimulator.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/tools/eventsystem/.qt/rcc/qrc_QuickStudioEventSystem_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/tools/eventsystem/.qt/rcc/qrc_qmake_QtQuick_Studio_EventSystem.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/components/.qt/rcc/qrc_qmake_QtQuick_Studio_Components.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/components/.qt/rcc/qrc_QuickStudioComponents_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/designeffects/.qt/rcc/qrc_designeffectsshaders.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/designeffects/.qt/rcc/qrc_QuickStudioDesignEffects_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/designeffects/.qt/rcc/qrc_qmake_QtQuick_Studio_DesignEffects.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/application/.qt/rcc/qrc_qmake_QtQuick_Studio_Application.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Profiling/.qt/rcc/qrc_qmake_QtQuickUltralite_Profiling.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Profiling/.qt/rcc/qrc_QuickUltraLiteStudioProfiling_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Layers/.qt/rcc/qrc_qmake_QtQuickUltralite_Layers.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Layers/.qt/rcc/qrc_QuickUltraLiteStudioLayers_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Components/.qt/rcc/qrc_qmake_QtQuickUltralite_Studio_Components.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Components/.qt/rcc/qrc_QuickUltraLiteStudioComponents_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Extras/.qt/rcc/qrc_qmake_QtQuickUltralite_Extras.cpp in package qtquickdesigner-components-src contains reference to TMPDIR
# File /usr/src/debug/qtquickdesigner-components/6.7.2/src/imports/compat/Extras/.qt/rcc/qrc_QuickUltraLiteStudioExtras_raw_qml_0.cpp in package qtquickdesigner-components-src contains reference to TMPDIR [buildpaths]
ERROR_QA:remove = "buildpaths"
WARN_QA:append = " buildpaths"
