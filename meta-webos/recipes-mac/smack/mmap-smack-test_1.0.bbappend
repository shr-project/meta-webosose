# https://lists.yoctoproject.org/g/yocto/message/63172
S = "${WORKDIR}/sources"
UNPACKDIR = "${S}"
