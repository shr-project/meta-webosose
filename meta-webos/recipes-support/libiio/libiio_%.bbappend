# Backport changes from:
# https://lists.openembedded.org/g/openembedded-devel/message/104710
# https://lists.openembedded.org/g/openembedded-devel/message/104709
# https://lists.openembedded.org/g/openembedded-devel/message/104708
inherit fix_branch_name
